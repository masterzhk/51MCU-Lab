# Keil uVision project Traffic Signal.uvproj, settings and files
target Target (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Traffic Signal +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group
    ./: STARTUP.A51 main.c
